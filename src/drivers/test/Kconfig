## src/drivers/test/Kconfig
```kconfig
menuconfig DRIVERS_TEST
	bool "test"
	default n
	---help---
		Enable support for test
```
